## boards/shields/zPad/Kconfig.defconfig
```kconfig
if SHIELD_ZPAD

config ZMK_KEYBOARD_NAME
    default "numpad"

endif # SHIELD_ZPAD
```
